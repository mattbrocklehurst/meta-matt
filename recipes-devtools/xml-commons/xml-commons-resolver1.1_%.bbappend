SRC_URI = "https://archive.apache.org/dist/xerces/xml-commons/xml-commons-resolver-1.2.tar.gz"

SRC_URI[md5sum] = "46d52acdb67ba60f0156043f30108766"
SRC_URI[sha256sum] = "55dbe7bd56452c175320ce9a97b752252c5537427221323c72e9b9c1ac221efe"
