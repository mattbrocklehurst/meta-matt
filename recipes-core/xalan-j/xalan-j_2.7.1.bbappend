SRC_URI = " \
    https://archive.apache.org/dist/xalan/xalan-j/source/xalan-j_2_7_1-src.tar.gz;name=archive \
    https://archive.apache.org/dist/commons/bsf/source/bsf-src-2.4.0.tar.gz;name=bsf \
"

SRC_URI[archive.md5sum] = "fc805051f0fe505c7a4b1b5c8db9b9e3"
SRC_URI[archive.sha256sum] = "fa52aa629bb882335d45d67401d270c3f21b5131aaea005ac0d4590f2ce8b043"

SRC_URI[bsf.md5sum] = "7e58b2a009c0f70ab36bbef420b25c07"
SRC_URI[bsf.sha256sum] = "5ab58cf5738c144f4d85a4a442c2f33be2c4c502dca6e29e0c570c2a51ae6ae9"
