SRC_URI = "https://sourceforge.net/projects/kaeilos/files/repo/jzlib-1.0.7.tar.gz"

SRC_URI[md5sum] = "3c52a0afb970e8a1fb2d34f30d330a83"
SRC_URI[sha256sum] = "20923a3f771a14c58c8cddfff2b589d568aff09f8a931919dc63ddaabb32407a"
