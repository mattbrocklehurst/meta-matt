SRC_URI = " \
	   https://archive.apache.org/dist/excalibur/excalibur-framework/source/avalon-framework-api-4.3-src.tar.gz;name=archive \
	   https://archive.apache.org/dist/avalon/logkit/source/logkit-1.2.2-src.tar.gz;name=logkit \
	  "

SRC_URI[avalon.md5sum] = "d4cffb4ba1d07bdc517ac6e322636495"
SRC_URI[avalon.sha256sum] = "a4d56a053609ddfc77f6a42c3f15a11708d5e0eb29ffc60a40b87e4cc7331d47"

SRC_URI[logkit.md5sum] = "996ee20d6b5785ab71f4692f64d10f9c"
SRC_URI[logkit.sha256sum] = "2c81edc87571fbd05797da7f65515e089c62cbb735bdbd10f93e29bd3aa3ddb8"
