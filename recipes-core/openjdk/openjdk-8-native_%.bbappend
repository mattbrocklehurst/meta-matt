FILESEXTRAPATHS:prepend := "${THISDIR}/openjdk-8:"
PATCHES_URI:append = " file://mbr_fix-gcc14-subsystems.patch"
